PACKAGECONFIG = "gsm"
PACKAGECONFIG[gsm] = ",,libgsm"
