PACKAGECONFIG = "shared"

PACKAGECONFIG[shared] = "--enable-shared,--disable-shared"
